options:
  parameters:
    author: franc
    generate_options: qt_gui
    id: iq
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: att
  id: variable_qtgui_range
  parameters:
    label: Attenuazione RF
    start: '0'
    step: '1'
    stop: '60'
    value: '17'
  states: {}
- name: mute
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '912000'
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: int(99e6)
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 912000 / (2*math.pi*75000)
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /dev/stdin
    repeat: 'True'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15-1
    vector_input: 'False'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: mute
    type: complex
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: att
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: tx_freq
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: '912000'
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8081'
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_selector_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_selector_0, '0', iio_pluto_sink_0, '0']
- [blocks_selector_0, '1', blocks_null_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
